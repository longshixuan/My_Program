# Keil uVision project stm32f103c8.uvprojx, settings and files
target stm32f103c8 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103c8 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\CMSIS;..\hardware\iwdg;..\hardware\KEY;..\hardware\LED;..\hardware\sys;..\hardware\TIMER;..\hardware\usart;..\Lib\inc;..\Lib\src;..\Startup;..\User;..\hardware\RTC;..\hardware\ADC;..\hardware\LSENS;..\hardware\OLED;..\hardware\HC_SR04;..\hardware\BH1750;..\hardware\dht11;..\hardware\SGP30;..\hardware\IIC;..\Gizwits;..\Utils;..\hardware\TIMER2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Startup/: startup_stm32f10x_md.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ../Lib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_adc.c stm32f10x_dma.c
  group hardware
    ../hardware/usart/: delay.c usart.c usart3.c usart2.c
    ../hardware/iwdg/: iwdg.c
    ../hardware/KEY/: key.c
    ../hardware/LED/: led.c
    ../hardware/sys/: sys.c
    ../hardware/TIMER/: timer.c
    ../hardware/RTC/: rtc.c
    ../hardware/ADC/: adc.c
    ../hardware/LSENS/: lsens.c
    ../hardware/dht11/: DHT11.c
    ../hardware/SGP30/: sgp30.c
    ../hardware/TIMER2/: TIM2.c
  group User
    ../User/: main.c stm32f10x_it.c
  group Gizwits
    ../Gizwits/: gizwits_product.c gizwits_protocol.c
  group Utils
    ../Utils/: common.c dataPointTools.c ringbuffer.c
software components: CMSIS:CORE 5.5.0
